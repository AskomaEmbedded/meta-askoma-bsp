SUMMARY = "Askoma image test"

inherit core-image 

EXTRA_IMAGE_FEATURES = "debug-tweaks ssh-server-openssh allow-root-login"
